# IAR project ili9341.ewp, settings and files
configuration ili9341 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ili9341.hex
  ILINK.IlinkOutputFile: ili9341.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: fonts.c fsmc.c gpio.c ili9341.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_fsmc.c
